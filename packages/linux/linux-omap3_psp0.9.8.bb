PSPREL = "0.9.8"
PR = "r2"

require linux-omap3_psp.inc
