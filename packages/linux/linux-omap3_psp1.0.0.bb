PSPREL = "1.0.0"
PR = "r3"

require linux-omap3_psp.inc
